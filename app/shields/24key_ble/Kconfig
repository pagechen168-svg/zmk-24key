## app/shields/24key_ble/Kconfig
```kconfig
menu "24 Key BLE Shield"

config SHIELD_24KEY_BLE
    bool "Enable 24key BLE shield"
    default y

endmenu
```
